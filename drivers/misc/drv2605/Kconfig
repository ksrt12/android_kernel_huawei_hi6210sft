## drivers/misc/drv2605/Kconfig
```kconfig
config DRV2605
	tristate "DRV1605 driver"
	default y
	help
	  Say Y to enable this driver
```
